# Keil uVision project FW_No_OS.uvproj, settings and files
target TC9562_PCIe_FW (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TC9562_FW_NoOS
  AfterMake: fromelf --bin ./Obj/TC9562_FW_NoOS.axf -o ./Bin/TC9562_Firmware_PCIeBridge.bin
  c flags: Optim=1 wLevel=2
  c include: .\Src\Include;..\Firmware
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group App
    ./Src/App/: main.c
    ./Src/: tc9562_MSI_Int.c
  group Startup
    ./Src/Startup/: tc9562_startup.s
  group Driver
    ./Src/: tc9562_emac.c tc9562_pcie.c tc9562_uart_driver.c tc9562_gpio_driver.c
